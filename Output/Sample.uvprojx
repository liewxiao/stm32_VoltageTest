# Keil uVision project Sample.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Sample +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\module_led;..\User\module_usart;..\User\freertos\include;..\User\freertos\portable;..\User\freertos;..\User\module_key;..\User\flexible_button;..\User\module_adc;..\User\lcd;..\User\menu;..\User\rtc;..\User\password;..\User\eeprom
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
    ../Libraries/CMSIS/: system_stm32f10x.c
  group USER
    ../User/: main.c stm32f10x_it.c global.c
    ../User/module_led/: module_led.c
    ../User/module_usart/: module_usart.c
    ../User/module_key/: module_key.c
    ../User/module_adc/: module_adc.c
    ../User/lcd/: bsp_ili9341_lcd.c fonts.c bsp_spi_flash.c
    ../User/menu/: menu.c
    ../User/rtc/: bsp_rtc.c bsp_date.c
    ../User/password/: password.c
    ../User/eeprom/: eeprom.c
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../Doc/: readme.txt
  group FreeRTOS
    ../User/freertos/: list.c queue.c tasks.c timers.c
    ../User/freertos/portable/: port.c
    ../User/freertos/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.6.0
